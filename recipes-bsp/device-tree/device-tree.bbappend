FILESEXTRAPATHS:prepend := "${THISDIR}/files:"




SRC_URI:append:xu3-module = " file://system-user.dtsi"
