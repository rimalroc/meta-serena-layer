FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://uio.cfg"