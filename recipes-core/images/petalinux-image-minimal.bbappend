IMAGE_INSTALL:append = " libgpiod libgpiod-tools"
#IMAGE_INSTALL:append = " myaccip-uio-noirq"