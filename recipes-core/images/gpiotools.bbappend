IMAGE_INSTALL:append = " libgpiod libgpiod-tools"